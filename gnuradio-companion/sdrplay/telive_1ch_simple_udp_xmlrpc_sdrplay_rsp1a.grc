<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>author</key><value>Jacek Lipkowski SQ5BPF</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>title</key><value>SQ5BPF Tetra live receiver 1ch simple UDP demo with fixed offset xmlrpc for SDRplay RSP1A</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>agc</value></param>
<param><key>choices</key><value>[0,1]</value></param>
<param><key>value</key><value>1</value></param>
<param><key>grid_pos</key><value>11,6,1,1</value></param>
<param><key>label</key><value>Channel AGC</value></param>
<param><key>labels</key><value>["OFF","ON"]</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>first_decim</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>first_port</value></param>
<param><key>value</key><value>42000</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>391.1e6</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>18,6,1,1</value></param>
<param><key>label</key><value>Frequency</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>frx1</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>'{0:3.4f}MHz'.format((freq+xlate_offset_fine1)/1000000.0)</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>17,6,1,1</value></param>
<param><key>label</key><value>RX frequency</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>if_samp_rate</value></param>
<param><key>value</key><value>samp_rate/first_decim</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>options_low_pass</value></param>
<param><key>value</key><value>12500</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>out_sample_rate</value></param>
<param><key>value</key><value>36000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ppm_corr</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>ppm_corr</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>7</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>ppm</value></param>
<param><key>max</key><value>100</value></param>
<param><key>min</key><value>-100</value></param>
<param><key>num_steps</key><value>200</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2000000</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>sdr_gain</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>20</value></param>
<param><key>grid_pos</key><value>1,6,1,1</value></param>
<param><key>label</key><value>Attenuation [dB]</value></param>
<param><key>max</key><value>60</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>61</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>telive_receiver_channels</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>telive_receiver_name</value></param>
<param><key>value</key><value>'SQ5BPF 1-channel rx for telive, SDRplay RSP-1A version'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>udp_dest_addr</value></param>
<param><key>value</key><value>"127.0.0.1"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>udp_packet_size</value></param>
<param><key>value</key><value>1472</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>var_agc_enabled</value></param>
<param><key>choices</key><value>[False,True]</value></param>
<param><key>value</key><value>True</value></param>
<param><key>grid_pos</key><value>3,6,1,1</value></param>
<param><key>label</key><value>AGC</value></param>
<param><key>labels</key><value>['OFF','ON']</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>var_biast</value></param>
<param><key>choices</key><value>[False,True]</value></param>
<param><key>value</key><value>False</value></param>
<param><key>grid_pos</key><value>4,6,1,1</value></param>
<param><key>label</key><value>Bias T</value></param>
<param><key>labels</key><value>['OFF','ON']</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>var_brnotch</value></param>
<param><key>choices</key><value>[False,True]</value></param>
<param><key>value</key><value>True</value></param>
<param><key>grid_pos</key><value>6,6,1,1</value></param>
<param><key>label</key><value>Broadcast Notch</value></param>
<param><key>labels</key><value>['OFF','ON']</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>var_dabnotch</value></param>
<param><key>choices</key><value>[False,True]</value></param>
<param><key>value</key><value>False</value></param>
<param><key>grid_pos</key><value>7,6,1,1</value></param>
<param><key>label</key><value>DAB Notch</value></param>
<param><key>labels</key><value>['OFF','ON']</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>var_dcoffset</value></param>
<param><key>choices</key><value>[False,True]</value></param>
<param><key>value</key><value>False</value></param>
<param><key>grid_pos</key><value>5,6,1,1</value></param>
<param><key>label</key><value>DC offset correction</value></param>
<param><key>labels</key><value>['OFF','ON']</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>var_iqbalance</value></param>
<param><key>choices</key><value>[False,True]</value></param>
<param><key>value</key><value>True</value></param>
<param><key>grid_pos</key><value>8,6,1,1</value></param>
<param><key>label</key><value>Auto IQ Balance</value></param>
<param><key>labels</key><value>['OFF','ON']</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>var_lna_atten_step</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>1</value></param>
<param><key>grid_pos</key><value>2,6,1,1</value></param>
<param><key>label</key><value>Attenuation step</value></param>
<param><key>max</key><value>8</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>9</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>"Please use M (mega) , k (kilo) sufixes where appropriate and press Enter after inputing text.\nPlease look at the gnuradio-companion console for possible errors (like PLL unlock etc)"</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>20,0,3,6</value></param>
<param><key>label</key><value>Notice</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>""</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,6,1,1</value></param>
<param><key>label</key><value>"SDRplay RSP settings"</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0_0_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>""</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>10,6,1,1</value></param>
<param><key>label</key><value>"Other receiver settings"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xlate_offset1</value></param>
<param><key>value</key><value>500000</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>xlate_offset_fine1</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>grid_pos</key><value>19,6,1,1</value></param>
<param><key>label</key><value>Fine Tune</value></param>
<param><key>max</key><value>10000</value></param>
<param><key>min</key><value>-10000</value></param>
<param><key>num_steps</key><value>200</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>analog_agc3_xx</key>
<param><key>id</key><value>analog_agc3_xx_0</value></param>
<param><key>attack_rate</key><value>1e-5</value></param>
<param><key>decay_rate</key><value>1e-5</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>iir_update_decim</key><value>1</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>reference</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0_0</value></param>
<param><key>ipaddr</key><value>udp_dest_addr</value></param>
<param><key>port</key><value>first_port+1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>psize</key><value>udp_packet_size</value></param>
<param><key>eof</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>fractional_resampler_xx</key>
<param><key>id</key><value>fractional_resampler_xx_0_0</value></param>
<param><key>phase_shift</key><value>0</value></param>
<param><key>resamp_ratio</key><value>float(float(if_samp_rate)/float(out_sample_rate))</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>xlate_offset1+xlate_offset_fine1</value></param>
<param><key>decim</key><value>first_decim</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>firdes.low_pass(1, samp_rate, options_low_pass, options_low_pass*0.2)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>gr_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1.0 if agc == 0 else 0.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>1.0 if agc == 1 else 0.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>sdrplay_rsp1a_source</key>
<param><key>id</key><value>sdrplay_rsp1a_source_0</value></param>
<param><key>agc_enabled</key><value>var_agc_enabled</value></param>
<param><key>bw</key><value>1536</value></param>
<param><key>biasT</key><value>var_biast</value></param>
<param><key>bcast_notch</key><value>var_brnotch</value></param>
<param><key>dab_notch</key><value>var_dabnotch</value></param>
<param><key>dc_offset_mode</key><value>var_dcoffset</value></param>
<param><key>debug_enabled</key><value>False</value></param>
<param><key>device_serial</key><value>'0'</value></param>
<param><key>if_atten_db</key><value>40</value></param>
<param><key>ifType</key><value>0</value></param>
<param><key>iq_balance_mode</key><value>var_iqbalance</value></param>
<param><key>lna_atten_step</key><value>0</value></param>
<param><key>lo_mode</key><value>1</value></param>
<param><key>rf_freq</key><value>freq-xlate_offset1</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>wxgui_constellationsink2</key>
<param><key>id</key><value>wxgui_constellationsink2_0</value></param>
<param><key>const_size</key><value>2048</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>frame_rate</key><value>10</value></param>
<param><key>gain_mu</key><value>0.005</value></param>
<param><key>loop_bw</key><value>6.28/100.0</value></param>
<param><key>M</key><value>4</value></param>
<param><key>fmax</key><value>0.06</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_limit</key><value>0.005</value></param>
<param><key>samp_rate</key><value>out_sample_rate</value></param>
<param><key>symbol_rate</key><value>out_sample_rate/4.</value></param>
<param><key>theta</key><value>0</value></param>
<param><key>title</key><value>Constellation Plot</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0.1</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>freq-xlate_offset1</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>freq</value></param>
<param><key>grid_pos</key><value>10,0,10,5</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>Full Spectrum  (click to tune)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0_0</value></param>
<param><key>avg_alpha</key><value>0.1</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>256</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>grid_pos</key><value>0,0,10,5</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>32</value></param>
<param><key>samp_rate</key><value>if_samp_rate</value></param>
<param><key>title</key><value>Channel 1 FFT</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>xmlrpc_server</key>
<param><key>id</key><value>xmlrpc_server_0</value></param>
<param><key>addr</key><value>0.0.0.0</value></param>
<param><key>port</key><value>first_port</value></param>
</block>
<connection><source_block_id>analog_agc3_xx_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fractional_resampler_xx_0_0</source_block_id><sink_block_id>blocks_udp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fractional_resampler_xx_0_0</source_block_id><sink_block_id>wxgui_constellationsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>analog_agc3_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_add_xx_0</source_block_id><sink_block_id>fractional_resampler_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_add_xx_0</source_block_id><sink_block_id>wxgui_fftsink2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>gr_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0_0</source_block_id><sink_block_id>gr_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>sdrplay_rsp1a_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sdrplay_rsp1a_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
