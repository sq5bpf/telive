<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>out_sample_rate</value></param>
<param><key>value</key><value>36000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>udp_first_port</value></param>
<param><key>value</key><value>42001</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>udp_dest_addr</value></param>
<param><key>value</key><value>"127.0.0.1"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>options_low_pass</value></param>
<param><key>value</key><value>12500</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>if_samp_rate</value></param>
<param><key>value</key><value>samp_rate/first_decim</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>first_decim</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>ppm_corr</value></param>
<param><key>label</key><value>ppm</value></param>
<param><key>value</key><value>56</value></param>
<param><key>min</key><value>-100</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>200</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,1,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>sdr_gain</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>38</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>42</value></param>
<param><key>num_steps</key><value>42</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,2,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>sdr_ifgain</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>20</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>30</value></param>
<param><key>num_steps</key><value>30</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,3,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>xlate_offset_fine1</value></param>
<param><key>label</key><value>Fine1</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-5000</value></param>
<param><key>max</key><value>5000</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>2,2,1,3</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>frx1</value></param>
<param><key>label</key><value>RX1</value></param>
<param><key>value</key><value>freq+xlate_offset1+xlate_offset_fine1</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>2,0,1,1</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>frx2</value></param>
<param><key>label</key><value>RX1</value></param>
<param><key>value</key><value>freq+xlate_offset2+xlate_offset_fine2</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>3,0,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>xlate_offset_fine2</value></param>
<param><key>label</key><value>Fine2</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-5000</value></param>
<param><key>max</key><value>5000</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>3,2,1,3</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>xlate_offset_fine3</value></param>
<param><key>label</key><value>Fine3</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-5000</value></param>
<param><key>max</key><value>5000</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>4,2,1,3</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>frx3</value></param>
<param><key>label</key><value>RX3</value></param>
<param><key>value</key><value>freq+xlate_offset3+xlate_offset_fine3</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>4,0,1,1</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Channel 1 FFT</value></param>
<param><key>samp_rate</key><value>if_samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>256</value></param>
<param><key>fft_rate</key><value>32</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.1</value></param>
<param><key>win</key><value>None</value></param>
<param><key>notebook</key><value>notebook1,0</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Channel 2 FFT</value></param>
<param><key>samp_rate</key><value>if_samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>256</value></param>
<param><key>fft_rate</key><value>32</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.1</value></param>
<param><key>win</key><value>None</value></param>
<param><key>notebook</key><value>notebook1,1</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Channel 3 FFT</value></param>
<param><key>samp_rate</key><value>if_samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>256</value></param>
<param><key>fft_rate</key><value>32</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.1</value></param>
<param><key>win</key><value>None</value></param>
<param><key>notebook</key><value>notebook1,2</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Center Freq</value></param>
<param><key>value</key><value>435e6</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>xlate_offset1</value></param>
<param><key>label</key><value>Offset1</value></param>
<param><key>value</key><value>500000</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>2,1,1,1</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>xlate_offset2</value></param>
<param><key>label</key><value>Offset2</value></param>
<param><key>value</key><value>-250000</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>3,1,1,1</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>xlate_offset3</value></param>
<param><key>label</key><value>Offset3</value></param>
<param><key>value</key><value>750000</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>4,1,1,1</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>xlate_offset4</value></param>
<param><key>label</key><value>Offset4</value></param>
<param><key>value</key><value>800000</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>5,1,1,1</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0_0_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Channel 4 FFT</value></param>
<param><key>samp_rate</key><value>if_samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>256</value></param>
<param><key>fft_rate</key><value>32</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.1</value></param>
<param><key>win</key><value>None</value></param>
<param><key>notebook</key><value>notebook1,3</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>frx4</value></param>
<param><key>label</key><value>RX4</value></param>
<param><key>value</key><value>freq+xlate_offset4+xlate_offset_fine4</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>5,0,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>xlate_offset_fine4</value></param>
<param><key>label</key><value>Fine4</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-5000</value></param>
<param><key>max</key><value>5000</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>5,2,1,3</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0_0_0_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Channel 5 FFT</value></param>
<param><key>samp_rate</key><value>if_samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>256</value></param>
<param><key>fft_rate</key><value>32</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.1</value></param>
<param><key>win</key><value>None</value></param>
<param><key>notebook</key><value>notebook1,4</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0_0_0_0_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Channel 6 FFT</value></param>
<param><key>samp_rate</key><value>if_samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>256</value></param>
<param><key>fft_rate</key><value>32</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.1</value></param>
<param><key>win</key><value>None</value></param>
<param><key>notebook</key><value>notebook1,5</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>notebook1</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>['F1', 'F2', 'F3','F4','F5','F6']</value></param>
<param><key>grid_pos</key><value>0,0,1,5</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>xlate_offset5</value></param>
<param><key>label</key><value>Offset5</value></param>
<param><key>value</key><value>825000</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>6,1,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>xlate_offset_fine5</value></param>
<param><key>label</key><value>Fine4</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-5000</value></param>
<param><key>max</key><value>5000</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>6,2,1,3</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>frx5</value></param>
<param><key>label</key><value>RX5</value></param>
<param><key>value</key><value>freq+xlate_offset5+xlate_offset_fine5</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>6,0,1,1</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>frx6</value></param>
<param><key>label</key><value>RX6</value></param>
<param><key>value</key><value>freq+xlate_offset6+xlate_offset_fine6</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>7,0,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>xlate_offset_fine6</value></param>
<param><key>label</key><value>Fine4</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-5000</value></param>
<param><key>max</key><value>5000</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>7,2,1,3</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>xlate_offset6</value></param>
<param><key>label</key><value>Offset6</value></param>
<param><key>value</key><value>725000</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>7,1,1,1</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>first_decim</value></param>
<param><key>taps</key><value>firdes.low_pass(1, samp_rate, options_low_pass, options_low_pass*0.2)</value></param>
<param><key>center_freq</key><value>xlate_offset1+xlate_offset_fine1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0_0_0_0_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>first_decim</value></param>
<param><key>taps</key><value>firdes.low_pass(1, samp_rate, options_low_pass, options_low_pass*0.2)</value></param>
<param><key>center_freq</key><value>xlate_offset6+xlate_offset_fine6</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>first_decim</value></param>
<param><key>taps</key><value>firdes.low_pass(1, samp_rate, options_low_pass, options_low_pass*0.2)</value></param>
<param><key>center_freq</key><value>xlate_offset2+xlate_offset_fine2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>first_decim</value></param>
<param><key>taps</key><value>firdes.low_pass(1, samp_rate, options_low_pass, options_low_pass*0.2)</value></param>
<param><key>center_freq</key><value>xlate_offset3+xlate_offset_fine3</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0_0_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>first_decim</value></param>
<param><key>taps</key><value>firdes.low_pass(1, samp_rate, options_low_pass, options_low_pass*0.2)</value></param>
<param><key>center_freq</key><value>xlate_offset4+xlate_offset_fine4</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0_0_0_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>first_decim</value></param>
<param><key>taps</key><value>firdes.low_pass(1, samp_rate, options_low_pass, options_low_pass*0.2)</value></param>
<param><key>center_freq</key><value>xlate_offset5+xlate_offset_fine5</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>corr0</key><value>ppm_corr</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>gain0</key><value>sdr_gain</value></param>
<param><key>if_gain0</key><value>sdr_ifgain</value></param>
<param><key>bb_gain0</key><value>20</value></param>
</block>
<block>
<key>fractional_resampler_xx</key>
<param><key>id</key><value>fractional_resampler_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>phase_shift</key><value>0</value></param>
<param><key>resamp_ratio</key><value>float(float(if_samp_rate)/float(out_sample_rate))</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ipaddr</key><value>udp_dest_addr</value></param>
<param><key>port</key><value>udp_first_port+0</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>fractional_resampler_xx</key>
<param><key>id</key><value>fractional_resampler_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>phase_shift</key><value>0</value></param>
<param><key>resamp_ratio</key><value>float(float(if_samp_rate)/float(out_sample_rate))</value></param>
</block>
<block>
<key>fractional_resampler_xx</key>
<param><key>id</key><value>fractional_resampler_xx_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>phase_shift</key><value>0</value></param>
<param><key>resamp_ratio</key><value>float(float(if_samp_rate)/float(out_sample_rate))</value></param>
</block>
<block>
<key>fractional_resampler_xx</key>
<param><key>id</key><value>fractional_resampler_xx_0_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>phase_shift</key><value>0</value></param>
<param><key>resamp_ratio</key><value>float(float(if_samp_rate)/float(out_sample_rate))</value></param>
</block>
<block>
<key>fractional_resampler_xx</key>
<param><key>id</key><value>fractional_resampler_xx_0_3</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>phase_shift</key><value>0</value></param>
<param><key>resamp_ratio</key><value>float(float(if_samp_rate)/float(out_sample_rate))</value></param>
</block>
<block>
<key>fractional_resampler_xx</key>
<param><key>id</key><value>fractional_resampler_xx_0_4</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>phase_shift</key><value>0</value></param>
<param><key>resamp_ratio</key><value>float(float(if_samp_rate)/float(out_sample_rate))</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0_3</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ipaddr</key><value>udp_dest_addr</value></param>
<param><key>port</key><value>udp_first_port+5</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0_4</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ipaddr</key><value>udp_dest_addr</value></param>
<param><key>port</key><value>udp_first_port+4</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ipaddr</key><value>udp_dest_addr</value></param>
<param><key>port</key><value>udp_first_port+3</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ipaddr</key><value>udp_dest_addr</value></param>
<param><key>port</key><value>udp_first_port+2</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ipaddr</key><value>udp_dest_addr</value></param>
<param><key>port</key><value>udp_first_port+1</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>title</key><value>SQ5BPF Tetra live receiver 6ch UDP demo (gnuradio 37 version)</value></param>
<param><key>author</key><value>Jacek Lipkowski SQ5BPF</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0</source_block_id><sink_block_id>wxgui_fftsink2_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_0</source_block_id><sink_block_id>wxgui_fftsink2_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_0_0</source_block_id><sink_block_id>wxgui_fftsink2_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_0_0_0</source_block_id><sink_block_id>wxgui_fftsink2_0_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_0_0_0_0</source_block_id><sink_block_id>wxgui_fftsink2_0_0_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>fractional_resampler_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>wxgui_fftsink2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_0_0_0_0</source_block_id><sink_block_id>fractional_resampler_xx_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0</source_block_id><sink_block_id>fractional_resampler_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_0</source_block_id><sink_block_id>fractional_resampler_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_0_0</source_block_id><sink_block_id>fractional_resampler_xx_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_0_0_0</source_block_id><sink_block_id>fractional_resampler_xx_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fractional_resampler_xx_0</source_block_id><sink_block_id>blocks_udp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fractional_resampler_xx_0_0</source_block_id><sink_block_id>blocks_udp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fractional_resampler_xx_0_1</source_block_id><sink_block_id>blocks_udp_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fractional_resampler_xx_0_2</source_block_id><sink_block_id>blocks_udp_sink_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fractional_resampler_xx_0_3</source_block_id><sink_block_id>blocks_udp_sink_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fractional_resampler_xx_0_4</source_block_id><sink_block_id>blocks_udp_sink_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
